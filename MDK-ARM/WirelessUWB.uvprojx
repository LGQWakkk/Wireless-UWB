# Keil uVision project WirelessUWB.uvprojx, settings and files
target WirelessUWB (6160000::V6.16::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: WirelessUWB +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../Components
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_adc.c stm32g0xx_ll_gpio.c stm32g0xx_ll_dma.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Components
    ../Components/: system.c mk8000.c si24r1.c utils.c
software components: CMSIS:CORE 5.4.0
